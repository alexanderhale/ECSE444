# Keil uVision project GXX_Lab0.uvprojx, settings and files
target GXX_Lab0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: GXX_Lab0
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ./inc; ./RTE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./src/: main.c add_c.c sma_c.c
  group asm
    ./asm/: add_asm.s sma_asm.s
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:Startup 1.0.1, Compiler:I/O:STDOUT 1.4.0
