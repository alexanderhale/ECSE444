<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\G19_Lab5_Alex.ewp</path>
  </project>
  <batchBuild />
</workspace>
